# Autodesk Inventor assembly: 21.1082 FLOOR ANCHOR 10
## iProperties
Created: 2007-04
Part Number: 21.1082 FLOOR ANCHOR 10
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
